# Keil uVision project Project.uvprojx, settings and files
target GD32E23x (6160000::V6.16::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\CODE;..\USER\src;..\USER\inc;..\..\Libraries\hefei_libraries;..\..\Libraries\hefei_peripheral;..\..\Libraries\Device\CMSIS\Keil_Common;..\..\Libraries\Device\GD32E23x_p\Include;..\..\Libraries\Device\GD32E23x_p\Source;..\..\Libraries\Device\GD32E23x_p\Source\KEIL_StartAsm;..\..\Libraries\Device\GD32E23x_p\GD32E23x_Lib\Inc;..\..\Libraries\Device\GD32E23x_p\GD32E23x_Lib\Head
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user_c
    ../USER/src/: gd32e23x_it.c main.c
  group user_h
    ../USER/inc/: gd32e23x_it.h main.h
  group CODE
    ../CODE/: 本文件夹作用.txt board.c board.h car_init.c car_init.h car_motion.c car_motion.h car_light.c car_light.h car_uart.c car_uart.h car_buzzer.c car_buzzer.h car_4keys.c car_4keys.h car_adc.c car_adc.h car_reed.c car_reed.h car_value_process.c car_value_process.h
  group startup
    ../../Libraries/Device/GD32E23x_p/Source/: system_gd32e23x.c
    ../../Libraries/Device/GD32E23x_p/Source/KEIL_StartAsm/: startup_gd32e23x.s
  group doc
    ../../Libraries/doc/: readme.txt
  group hefei_libraries
    ../../Libraries/hefei_libraries/: headfile.h hf_adc.c hf_adc.h hf_exti.c hf_exti.h hf_flash.c hf_flash.h hf_gpio.c hf_gpio.h hf_i2c_hardware.c hf_i2c_hardware.h hf_i2c_software.c hf_i2c_software.h hf_pit.c hf_pit.h hf_pwm.c hf_pwm.h hf_qtimer.c hf_qtimer.h hf_spi.c hf_spi.h hf_systick.c hf_systick.h hf_uart.c hf_uart.h
  group hefei_peripheral
    ../../Libraries/hefei_peripheral/: HF_L9110S_2.c HF_L9110S_2.h HF_WS2812b.c HF_WS2812b.h HF_HC-SR04.c HF_HC-SR04.h HF_TM1637.c HF_TM1637.h
  group GD32E23x
    ../../Libraries/Device/GD32E23x_p/GD32E23x_Lib/Head/: gd32e23x_libopt.h
    ../../Libraries/Device/GD32E23x_p/GD32E23x_Lib/Src/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
    ../../Libraries/Device/GD32E23x_p/GD32E23x_Lib/Inc/: gd32e23x_adc.h gd32e23x_cmp.h gd32e23x_crc.h gd32e23x_dbg.h gd32e23x_dma.h gd32e23x_exti.h gd32e23x_fmc.h gd32e23x_fwdgt.h gd32e23x_gpio.h gd32e23x_i2c.h gd32e23x_misc.h gd32e23x_pmu.h gd32e23x_rcu.h gd32e23x_rtc.h gd32e23x_spi.h gd32e23x_syscfg.h gd32e23x_timer.h gd32e23x_usart.h gd32e23x_wwdgt.h
software components: CMSIS:CORE 5.0.2
